#include "LightbulbFont.h"

#include <array>

namespace {
constexpr uint32_t kLightbulbCodepoint = 0xF0EB;
constexpr uint32_t kSunCodepoint = 0xF185;
constexpr uint8_t kFlamesBitmap[] = {
    0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x1D, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0xE4, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0xED, 0x20, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x01, 0xCE, 0xEE, 0xA0, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x09, 0xEE, 0xEE, 0xE4, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x4E, 0xEE, 0xEE, 0xEA, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x03, 0xDE, 0xEE, 0xEE, 0xEE, 0x10, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x3D, 0xEE, 0xEE, 0xEE, 0xEE, 0x60, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x03, 0xDE, 0xEE, 0xEE, 0xEE, 0xEE, 0x80, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x1C, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xA0, 0x03, 0x00, 0x00,
    0x00, 0x00, 0x7E, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xB0, 0x1C, 0x20, 0x00,
    0x00, 0x00, 0xCE, 0xEE, 0xEE, 0xEE, 0xCE, 0xEE, 0xA0, 0x9E, 0x30, 0x00,
    0x00, 0x03, 0xEE, 0xEE, 0xEE, 0xE7, 0x6E, 0xEE, 0xBB, 0xEE, 0x40, 0x00,
    0x00, 0x05, 0xEE, 0xEE, 0xEE, 0xB1, 0x2E, 0xEE, 0xEE, 0xEE, 0x50, 0x00,
    0x00, 0x06, 0xEE, 0xEE, 0xEE, 0x40, 0x08, 0xEE, 0xEE, 0xEE, 0x60, 0x00,
    0x00, 0x06, 0xEE, 0xEE, 0xEC, 0x00, 0x00, 0x8E, 0xEE, 0xEE, 0x60, 0x00,
    0x00, 0x04, 0xEE, 0xEE, 0xC8, 0x00, 0x00, 0x0A, 0xEE, 0xEE, 0x40, 0x00,
    0x00, 0x01, 0xDE, 0xEE, 0x48, 0x00, 0x00, 0x02, 0xEE, 0xED, 0x10, 0x00,
    0x00, 0x00, 0x9E, 0xEC, 0x01, 0x00, 0x00, 0x00, 0xDE, 0xE9, 0x00, 0x00,
    0x00, 0x00, 0x2D, 0xEC, 0x00, 0x00, 0x00, 0x00, 0xCE, 0xD2, 0x00, 0x00,
    0x00, 0x00, 0x04, 0xDE, 0x00, 0x00, 0x00, 0x00, 0xED, 0x40, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x3C, 0x60, 0x00, 0x00, 0x06, 0xC3, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x01, 0x52, 0x00, 0x00, 0x25, 0x10, 0x00, 0x00, 0x00,
};

constexpr uint8_t kSpigotBitmap[] = {
    0x00, 0x00, 0x04, 0x42, 0x00, 0x4E, 0xD1, 0x01, 0x24, 0x30, 0x00, 0x00,
    0x00, 0x00, 0x6F, 0xFF, 0xFD, 0xEF, 0xFD, 0xEF, 0xFF, 0xF2, 0x00, 0x00,
    0x00, 0x00, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF4, 0x00, 0x00,
    0x00, 0x00, 0x4F, 0xFD, 0xA8, 0xCF, 0xFA, 0x8B, 0xEF, 0xD1, 0x00, 0x00,
    0x00, 0x00, 0x01, 0x10, 0x00, 0x2E, 0xC0, 0x00, 0x01, 0x10, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0xC1, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x08, 0xFF, 0xFE, 0x40, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x0B, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x1C, 0xFF, 0xFF, 0x91, 0x00, 0x00, 0x00, 0x00,
    0x24, 0x00, 0x00, 0x00, 0xBF, 0xFF, 0xFF, 0xE7, 0x00, 0x00, 0x00, 0x00,
    0xAC, 0x00, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFD, 0x00, 0x00, 0x00, 0x00,
    0xBD, 0x00, 0x00, 0x05, 0xFF, 0xFF, 0xFF, 0xFF, 0x20, 0x00, 0x00, 0x00,
    0xBE, 0xAA, 0xAA, 0xAD, 0xFF, 0xFF, 0xFF, 0xFF, 0xC9, 0x72, 0x00, 0x00,
    0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x60, 0x00,
    0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
    0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x30,
    0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x90,
    0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1,
    0xBF, 0xCC, 0xCC, 0xCE, 0xFF, 0xFF, 0xFF, 0xFF, 0xEE, 0xFF, 0xFF, 0xF4,
    0xBD, 0x00, 0x00, 0x02, 0xEF, 0xFF, 0xFF, 0xFC, 0x10, 0xCF, 0xFF, 0xF6,
    0xBD, 0x00, 0x00, 0x00, 0x4D, 0xFF, 0xFF, 0xB1, 0x00, 0x4F, 0xFF, 0xF9,
    0x8B, 0x00, 0x00, 0x00, 0x03, 0xAE, 0xE8, 0x10, 0x00, 0x3F, 0xFF, 0xFA,
    0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFA,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x2F, 0xFF, 0xF9,
};

constexpr uint8_t kFanBitmap[] = {
    0x00, 0x00, 0x02, 0x9D, 0xEB, 0x20, 0x00, 0x00, 0x11, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x8E, 0xFF, 0xFF, 0xD0, 0x00, 0x1B, 0xFF, 0xD6, 0x00, 0x00,
    0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xF2, 0x00, 0xAF, 0xFF, 0xFF, 0x70, 0x00,
    0x00, 0x5F, 0xFF, 0xFF, 0xFF, 0xF2, 0x06, 0xFF, 0xFF, 0xFF, 0xF5, 0x00,
    0x00, 0xDF, 0xFF, 0xFF, 0xFF, 0xF2, 0x1E, 0xFF, 0xFF, 0xFF, 0xFE, 0x10,
    0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xF2, 0x5F, 0xFF, 0xFF, 0xFF, 0xFF, 0x70,
    0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF2, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
    0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xF5, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
    0x00, 0x9F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
    0x00, 0x1B, 0xFF, 0xFF, 0xFF, 0xD7, 0x7D, 0xFF, 0xFF, 0xFF, 0xFF, 0xB0,
    0x00, 0x01, 0x8E, 0xFF, 0xFE, 0x25, 0x43, 0xEF, 0xFF, 0xFF, 0xFD, 0x20,
    0x00, 0x00, 0x02, 0x9E, 0xF9, 0x4F, 0xF3, 0x9C, 0x32, 0x22, 0x21, 0x00,
    0x00, 0x01, 0x11, 0x22, 0xD8, 0x4F, 0xF3, 0x9F, 0xD7, 0x10, 0x00, 0x00,
    0x02, 0xCE, 0xFF, 0xFF, 0xFD, 0x27, 0x62, 0xEF, 0xFF, 0xD6, 0x00, 0x00,
    0x0B, 0xFF, 0xFF, 0xFF, 0xFF, 0xC5, 0x6C, 0xFF, 0xFF, 0xFF, 0x91, 0x00,
    0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
    0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x6F, 0xFF, 0xFF, 0xFF, 0xFF, 0x10,
    0x0D, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x30,
    0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xF5, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x20,
    0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0x3F, 0xFF, 0xFF, 0xFF, 0xFD, 0x00,
    0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x60, 0x3F, 0xFF, 0xFF, 0xFF, 0xF5, 0x00,
    0x00, 0x09, 0xFF, 0xFF, 0xFA, 0x00, 0x2F, 0xFF, 0xFF, 0xFF, 0x90, 0x00,
    0x00, 0x00, 0x8E, 0xFF, 0xB1, 0x00, 0x1E, 0xFF, 0xFF, 0xF9, 0x00, 0x00,
    0x00, 0x00, 0x01, 0x22, 0x00, 0x00, 0x03, 0xDF, 0xEA, 0x30, 0x00, 0x00,
};

constexpr uint32_t kFlamesCodepoint = 0xE001;
constexpr uint32_t kSpigotCodepoint = 0xE000;
constexpr uint32_t kFanCodepoint = 0xF863;
constexpr uint32_t kPowerCordCodepoint = 0xF1E6;
constexpr uint32_t kThermometerCodepoint = 0xF2C7;
constexpr uint32_t kHumidityCodepoint = 0xF773;

// Four-bit alpha mask converted from the supplied 14 x 24 PNG. Two pixels are
// packed in each byte, preserving its anti-aliased edges without a PNG decoder.
constexpr uint8_t kLightbulbBitmap[] = {
    0x00, 0x04, 0x9C, 0xEC, 0xA4, 0x00, 0x00,
    0x01, 0x9F, 0xFF, 0xFF, 0xFF, 0xA1, 0x00,
    0x0A, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0x00,
    0x5F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x60,
    0xAF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xB0,
    0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
    0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
    0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xD0,
    0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x90,
    0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x40,
    0x0B, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
    0x05, 0xFF, 0xFF, 0xFF, 0xFF, 0xF6, 0x00,
    0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0x00,
    0x00, 0xBF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
    0x00, 0x8F, 0xFF, 0xFF, 0xFF, 0x90, 0x00,
    0x00, 0x5F, 0xFF, 0xFF, 0xFF, 0x70, 0x00,
    0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x40, 0x00,
    0x00, 0x1A, 0xCC, 0xCC, 0xCA, 0x10, 0x00,
    0x00, 0x02, 0x22, 0x22, 0x22, 0x00, 0x00,
    0x00, 0x06, 0x77, 0x77, 0x76, 0x10, 0x00,
    0x00, 0x00, 0x11, 0x11, 0x10, 0x00, 0x00,
    0x00, 0x01, 0x78, 0x88, 0x71, 0x00, 0x00,
    0x00, 0x00, 0x14, 0x54, 0x10, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
};

// Four-bit alpha mask converted from the supplied 22 x 22 sun PNG.
constexpr uint8_t kSunBitmap[] = {
    0x00, 0x00, 0x00, 0x00, 0x02, 0xB3, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x04, 0xD5, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x01, 0x00, 0x00, 0x04, 0xD5, 0x00, 0x00, 0x01, 0x00, 0x00,
    0x00, 0x1C, 0x80, 0x00, 0x01, 0x92, 0x00, 0x00, 0x7D, 0x20, 0x00,
    0x00, 0x09, 0xD8, 0x00, 0x00, 0x00, 0x00, 0x06, 0xDA, 0x00, 0x00,
    0x00, 0x00, 0x9A, 0x00, 0x02, 0x43, 0x00, 0x09, 0xA1, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x03, 0xBD, 0xDD, 0xC4, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x3D, 0xA5, 0x24, 0xAD, 0x50, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0xBA, 0x10, 0x00, 0x09, 0xC1, 0x00, 0x00, 0x00,
    0x23, 0x31, 0x03, 0xD5, 0x00, 0x00, 0x03, 0xD4, 0x01, 0x33, 0x20,
    0xBD, 0xD9, 0x05, 0xD2, 0x00, 0x00, 0x00, 0xD6, 0x07, 0xDD, 0xC0,
    0x35, 0x52, 0x03, 0xD4, 0x00, 0x00, 0x03, 0xD4, 0x02, 0x55, 0x40,
    0x00, 0x00, 0x01, 0xC9, 0x00, 0x00, 0x08, 0xC1, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x5D, 0x93, 0x02, 0x8D, 0x60, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x05, 0xCD, 0xCD, 0xC6, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x68, 0x00, 0x14, 0x65, 0x20, 0x07, 0x70, 0x00, 0x00,
    0x00, 0x07, 0xD9, 0x00, 0x00, 0x00, 0x00, 0x08, 0xD8, 0x00, 0x00,
    0x00, 0x1D, 0xA1, 0x00, 0x01, 0x71, 0x00, 0x00, 0x9D, 0x20, 0x00,
    0x00, 0x02, 0x00, 0x00, 0x03, 0xD5, 0x00, 0x00, 0x03, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x04, 0xD5, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x02, 0xD4, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00,
};

// Four-bit alpha mask converted from the supplied 24 x 17 power-cord PNG.
constexpr uint8_t kPowerCordBitmap[] = {
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x59, 0xCD, 0xD9, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0xDD, 0xDD, 0xDB, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x26, 0x66, 0xAD, 0xDD, 0xDD, 0xDD, 0x77, 0x73,
    0x00, 0x00, 0x00, 0x00, 0xBD, 0xDD, 0xDD, 0xDD, 0xDD, 0xDD, 0xDD, 0xD8,
    0x00, 0x14, 0x55, 0x56, 0xDD, 0xDD, 0xDD, 0xDD, 0xDD, 0xDD, 0x44, 0x41,
    0x09, 0xDD, 0xDD, 0xDD, 0xDD, 0xDD, 0xDD, 0xDD, 0xDD, 0xDB, 0x00, 0x00,
    0x7D, 0x83, 0x22, 0x23, 0xDD, 0xDD, 0xDD, 0xDD, 0xDD, 0xDD, 0x66, 0x62,
    0xBA, 0x00, 0x00, 0x00, 0xAD, 0xDD, 0xDD, 0xDD, 0xDD, 0xDD, 0xDD, 0xD8,
    0xBA, 0x00, 0x00, 0x00, 0x03, 0x44, 0x8D, 0xDD, 0xDD, 0xDD, 0x55, 0x51,
    0x8D, 0x73, 0x22, 0x22, 0x10, 0x00, 0x05, 0xDD, 0xDD, 0xDB, 0x00, 0x00,
    0x19, 0xDD, 0xDD, 0xDD, 0xDA, 0x40, 0x00, 0x37, 0xAB, 0xB7, 0x00, 0x00,
    0x00, 0x25, 0x66, 0x66, 0x7B, 0xC3, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0xB9, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x05, 0xD6, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0xBB, 0xBB, 0xBB, 0xBB, 0xCD, 0xA1, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x99, 0x99, 0x99, 0x99, 0x85, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
};

// Four-bit alpha thermometer mask matching the compact header artwork.
constexpr uint8_t kThermometerBitmap[] = {
    0x00, 0x03, 0xDD, 0x30, 0x03, 0x30, 0x00,
    0x00, 0x0B, 0xDD, 0xB0, 0x0C, 0xC0, 0x00,
    0x00, 0x0D, 0x66, 0xD0, 0x00, 0x00, 0x00,
    0x00, 0x0D, 0x66, 0xD0, 0x0A, 0xA0, 0x00,
    0x00, 0x0D, 0x66, 0xD0, 0x0A, 0xA0, 0x00,
    0x00, 0x0D, 0x66, 0xD0, 0x00, 0x00, 0x00,
    0x00, 0x0D, 0x66, 0xD0, 0x0A, 0xA0, 0x00,
    0x00, 0x0D, 0x66, 0xD0, 0x0A, 0xA0, 0x00,
    0x00, 0x0D, 0x66, 0xD0, 0x00, 0x00, 0x00,
    0x00, 0x0D, 0x66, 0xD0, 0x0A, 0xA0, 0x00,
    0x00, 0x0D, 0x66, 0xD0, 0x0A, 0xA0, 0x00,
    0x00, 0x0D, 0x66, 0xD0, 0x00, 0x00, 0x00,
    0x00, 0x0D, 0xFF, 0xD0, 0x00, 0x00, 0x00,
    0x00, 0x0D, 0xFF, 0xD0, 0x00, 0x00, 0x00,
    0x00, 0x0D, 0xFF, 0xD0, 0x00, 0x00, 0x00,
    0x00, 0x0D, 0xFF, 0xD0, 0x00, 0x00, 0x00,
    0x00, 0x1D, 0xFF, 0xD1, 0x00, 0x00, 0x00,
    0x00, 0xBF, 0xFF, 0xFB, 0x00, 0x00, 0x00,
    0x03, 0xFF, 0xFF, 0xFF, 0x30, 0x00, 0x00,
    0x0B, 0xFF, 0xFF, 0xFF, 0xB0, 0x00, 0x00,
    0x0D, 0xFF, 0xFF, 0xFF, 0xD0, 0x00, 0x00,
    0x0B, 0xFF, 0xFF, 0xFF, 0xB0, 0x00, 0x00,
    0x03, 0xDF, 0xFF, 0xFD, 0x30, 0x00, 0x00,
    0x00, 0x1B, 0xDD, 0xB1, 0x00, 0x00, 0x00,
};

// Four-bit alpha mask converted from the supplied 26 x 22 humidity PNG.
constexpr uint8_t kHumidityBitmap[] = {
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x13, 0x31, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x8B, 0xDD, 0xDD, 0x92, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x8D, 0xC9, 0x64, 0x47, 0xC8, 0x00, 0x00,
    0x00, 0x05, 0x40, 0x00, 0x02, 0x8C, 0xC7, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x0A, 0xDB, 0x9A, 0xCD, 0xC7, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x01, 0x59, 0xBB, 0x86, 0x10, 0x00, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x58, 0xB2, 0x4D, 0xB0, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x5B, 0xDC, 0x60, 0xBD, 0xD6, 0x00, 0x00,
    0x00, 0x02, 0x10, 0x00, 0x00, 0x5B, 0xDA, 0x40, 0x05, 0xDD, 0xDC, 0x10, 0x00,
    0x00, 0x0B, 0xC8, 0x67, 0x9C, 0xDA, 0x40, 0x00, 0x0B, 0xDD, 0xDD, 0x70, 0x00,
    0x00, 0x02, 0x8C, 0xDD, 0xB9, 0x40, 0x00, 0x00, 0x6D, 0xDD, 0xDD, 0xC1, 0x00,
    0x00, 0x00, 0x00, 0x11, 0x00, 0x00, 0x00, 0x10, 0xBD, 0xDD, 0xDD, 0xD7, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x28, 0x62, 0xDD, 0xDD, 0xDD, 0xDA, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x28, 0xDC, 0x24, 0xDD, 0xDD, 0xDD, 0xDC, 0x00,
    0x00, 0x0B, 0xA5, 0x34, 0x69, 0xDC, 0x71, 0x02, 0xDD, 0xDD, 0xDD, 0xDA, 0x00,
    0x00, 0x05, 0xBD, 0xDD, 0xDC, 0x71, 0x00, 0x00, 0xBD, 0xDD, 0xDD, 0xD6, 0x00,
    0x00, 0x00, 0x03, 0x44, 0x10, 0x00, 0x00, 0x00, 0x2B, 0xDD, 0xDD, 0x80, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x58, 0x74, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
};

constexpr uint8_t kHeaderIconSize = 24;
constexpr size_t kHeaderIconBytes =
    (kHeaderIconSize * kHeaderIconSize) / 2;
using HeaderIconBitmap = std::array<uint8_t, kHeaderIconBytes>;
constexpr uint8_t kToolbarLightWidth = 10;
constexpr uint8_t kToolbarLightHeight = 18;
using ToolbarLightBitmap =
    std::array<uint8_t,
               ((kToolbarLightWidth + 1) / 2) * kToolbarLightHeight>;

uint8_t alphaAt(const uint8_t* bitmap, uint8_t width, uint8_t x,
                uint8_t y) {
  const size_t stride = (width + 1) / 2;
  const uint8_t packed = bitmap[y * stride + x / 2];
  return (x & 1) ? packed & 0x0F : packed >> 4;
}

void setAlpha(HeaderIconBitmap& bitmap, uint8_t x, uint8_t y,
              uint8_t alpha) {
  uint8_t& packed = bitmap[y * (kHeaderIconSize / 2) + x / 2];
  if (x & 1) packed = static_cast<uint8_t>((packed & 0xF0) | alpha);
  else packed = static_cast<uint8_t>((packed & 0x0F) | (alpha << 4));
}

HeaderIconBitmap fitHeaderIcon(const uint8_t* source, uint8_t sourceWidth,
                               uint8_t sourceHeight) {
  HeaderIconBitmap result{};
  uint8_t width = kHeaderIconSize;
  uint8_t height = kHeaderIconSize;
  if (sourceWidth > sourceHeight) {
    height = static_cast<uint8_t>((sourceHeight * kHeaderIconSize +
                                   sourceWidth / 2) / sourceWidth);
  } else if (sourceHeight > sourceWidth) {
    width = static_cast<uint8_t>((sourceWidth * kHeaderIconSize +
                                  sourceHeight / 2) / sourceHeight);
  }
  const uint8_t offsetX = (kHeaderIconSize - width) / 2;
  const uint8_t offsetY = (kHeaderIconSize - height) / 2;
  for (uint8_t y = 0; y < height; ++y) {
    const uint8_t sourceY = static_cast<uint8_t>(y * sourceHeight / height);
    for (uint8_t x = 0; x < width; ++x) {
      const uint8_t sourceX = static_cast<uint8_t>(x * sourceWidth / width);
      setAlpha(result, offsetX + x, offsetY + y,
               alphaAt(source, sourceWidth, sourceX, sourceY));
    }
  }
  return result;
}

ToolbarLightBitmap fitToolbarLightbulb() {
  ToolbarLightBitmap result{};
  constexpr size_t stride = (kToolbarLightWidth + 1) / 2;
  for (uint8_t y = 0; y < kToolbarLightHeight; ++y) {
    const uint8_t sourceY = static_cast<uint8_t>(y * 24 /
                                                 kToolbarLightHeight);
    for (uint8_t x = 0; x < kToolbarLightWidth; ++x) {
      const uint8_t sourceX = static_cast<uint8_t>(x * 14 /
                                                   kToolbarLightWidth);
      const uint8_t alpha = alphaAt(kLightbulbBitmap, 14, sourceX, sourceY);
      uint8_t& packed = result[y * stride + x / 2];
      if (x & 1) packed = static_cast<uint8_t>((packed & 0xF0) | alpha);
      else packed = static_cast<uint8_t>((packed & 0x0F) | (alpha << 4));
    }
  }
  return result;
}

const HeaderIconBitmap kHeaderThermometerBitmap =
    fitHeaderIcon(kThermometerBitmap, 14, 24);
const HeaderIconBitmap kHeaderHumidityBitmap =
    fitHeaderIcon(kHumidityBitmap, 26, 22);
const HeaderIconBitmap kHeaderPowerCordBitmap =
    fitHeaderIcon(kPowerCordBitmap, 24, 17);
const ToolbarLightBitmap kToolbarLightbulbBitmap = fitToolbarLightbulb();

bool getGlyphDsc14(const lv_font_t*, lv_font_glyph_dsc_t* dsc,
                   uint32_t letter, uint32_t) {
  if (letter != kLightbulbCodepoint) return false;
  dsc->adv_w = 14;
  dsc->box_w = kToolbarLightWidth;
  dsc->box_h = kToolbarLightHeight;
  dsc->ofs_x = 2;
  dsc->ofs_y = 0;
  dsc->stride = (kToolbarLightWidth + 1) / 2;
  dsc->format = LV_FONT_GLYPH_FORMAT_A4;
  dsc->gid.index = 1;
  dsc->is_placeholder = false;
  return true;
}

bool getGlyphDsc28(const lv_font_t*, lv_font_glyph_dsc_t* dsc,
                   uint32_t letter, uint32_t) {
  if (letter == kLightbulbCodepoint) {
    dsc->adv_w = 16;
    dsc->box_w = 14;
    dsc->box_h = 24;
    dsc->ofs_x = 1;
    dsc->ofs_y = 0;
  } else if (letter == kPowerCordCodepoint) {
    dsc->adv_w = 26;
    dsc->box_w = 24;
    dsc->box_h = 17;
    dsc->ofs_x = 1;
    dsc->ofs_y = 4;
  } else if (letter == kFanCodepoint || letter == kSpigotCodepoint || letter == kFlamesCodepoint) {
    dsc->adv_w = 26; dsc->box_w = 24; dsc->box_h = 24;
    dsc->ofs_x = 1; dsc->ofs_y = 0;
  } else {
    return false;
  }
  dsc->stride = (dsc->box_w + 1) / 2;
  dsc->format = LV_FONT_GLYPH_FORMAT_A4;
  dsc->gid.index = letter == kLightbulbCodepoint ? 1 : letter == kPowerCordCodepoint ? 2
                   : letter == kFanCodepoint ? 3 : letter == kSpigotCodepoint ? 4 : 5;
  dsc->is_placeholder = false;
  return true;
}

const void* renderA4Glyph(const uint8_t* source, lv_font_glyph_dsc_t* dsc,
                          lv_draw_buf_t* drawBuffer) {
  if (source == nullptr) return nullptr;
  if (dsc->req_raw_bitmap) return source;
  if (drawBuffer == nullptr) return nullptr;
  for (uint16_t y = 0; y < dsc->box_h; ++y) {
    uint8_t* output = drawBuffer->data + y * drawBuffer->header.stride;
    const uint8_t* input = source + y * dsc->stride;
    for (uint16_t x = 0; x < dsc->box_w; ++x) {
      const uint8_t packed = input[x / 2];
      const uint8_t alpha = (x & 1U) ? (packed & 0x0F) : (packed >> 4);
      output[x] = static_cast<uint8_t>(alpha * 17U);
    }
  }
  lv_draw_buf_flush_cache(drawBuffer, nullptr);
  return drawBuffer;
}

const void* getGlyphBitmap14(lv_font_glyph_dsc_t* dsc,
                             lv_draw_buf_t* drawBuffer) {
  return renderA4Glyph(
      dsc->gid.index == 1 ? kToolbarLightbulbBitmap.data() : nullptr,
      dsc, drawBuffer);
}

const void* getGlyphBitmap28(lv_font_glyph_dsc_t* dsc,
                             lv_draw_buf_t* drawBuffer) {
  const uint8_t* source = dsc->gid.index == 1 ? kLightbulbBitmap
                           : dsc->gid.index == 5 ? kFlamesBitmap
                           : dsc->gid.index == 4 ? kSpigotBitmap
                           : dsc->gid.index == 3 ? kFanBitmap
                           : dsc->gid.index == 2 ? kPowerCordBitmap
                                                 : nullptr;
  return renderA4Glyph(source, dsc, drawBuffer);
}

bool getGlyphDscSun24(const lv_font_t*, lv_font_glyph_dsc_t* dsc,
                      uint32_t letter, uint32_t) {
  if (letter != kSunCodepoint) return false;
  dsc->adv_w = 24;
  dsc->box_w = 22;
  dsc->box_h = 22;
  dsc->ofs_x = 1;
  dsc->ofs_y = 0;
  dsc->stride = 11;
  dsc->format = LV_FONT_GLYPH_FORMAT_A4;
  dsc->gid.index = 1;
  dsc->is_placeholder = false;
  return true;
}

const void* getGlyphBitmapSun24(lv_font_glyph_dsc_t* dsc,
                                lv_draw_buf_t* drawBuffer) {
  return renderA4Glyph(
      dsc->gid.index == 1 ? kSunBitmap : nullptr, dsc, drawBuffer);
}

bool getGlyphDscClimate24(const lv_font_t*, lv_font_glyph_dsc_t* dsc,
                          uint32_t letter, uint32_t) {
  if (letter == kThermometerCodepoint) {
    dsc->adv_w = 24;
    dsc->box_w = kHeaderIconSize;
    dsc->box_h = kHeaderIconSize;
    dsc->ofs_x = 1;
    dsc->ofs_y = -3;
  } else if (letter == kHumidityCodepoint) {
    dsc->adv_w = 24;
    dsc->box_w = kHeaderIconSize;
    dsc->box_h = kHeaderIconSize;
    dsc->ofs_x = 1;
    dsc->ofs_y = -3;
  } else if (letter == kPowerCordCodepoint) {
    dsc->adv_w = 24;
    dsc->box_w = kHeaderIconSize;
    dsc->box_h = kHeaderIconSize;
    dsc->ofs_x = 1;
    dsc->ofs_y = -3;
  } else {
    return false;
  }
  dsc->stride = kHeaderIconSize / 2;
  dsc->format = LV_FONT_GLYPH_FORMAT_A4;
  if (letter == kThermometerCodepoint) dsc->gid.index = 1;
  else if (letter == kHumidityCodepoint) dsc->gid.index = 2;
  else dsc->gid.index = 3;
  dsc->is_placeholder = false;
  return true;
}

const void* getGlyphBitmapClimate24(lv_font_glyph_dsc_t* dsc,
                                    lv_draw_buf_t* drawBuffer) {
  const uint8_t* source =
      dsc->gid.index == 1 ? kHeaderThermometerBitmap.data()
      : dsc->gid.index == 2 ? kHeaderHumidityBitmap.data()
      : dsc->gid.index == 3 ? kHeaderPowerCordBitmap.data()
                            : nullptr;
  return renderA4Glyph(source, dsc, drawBuffer);
}
}  // namespace

const lv_font_t bluesquid_font_lightbulb_14 = {
    .dsc = nullptr,
    .fallback = nullptr,
    .get_glyph_dsc = getGlyphDsc14,
    .get_glyph_bitmap = getGlyphBitmap14,
    .line_height = 18,
    .base_line = 2,
    .subpx = LV_FONT_SUBPX_NONE,
    .static_bitmap = 1,
    .underline_position = -2,
    .underline_thickness = 1,
};

const lv_font_t bluesquid_font_lightbulb_28 = {
    .dsc = nullptr,
    .fallback = nullptr,
    .get_glyph_dsc = getGlyphDsc28,
    .get_glyph_bitmap = getGlyphBitmap28,
    .line_height = 32,
    .base_line = 3,
    .subpx = LV_FONT_SUBPX_NONE,
    .static_bitmap = 1,
    .underline_position = -3,
    .underline_thickness = 1,
};

const lv_font_t bluesquid_font_sun_24 = {
    .dsc = nullptr,
    .fallback = nullptr,
    .get_glyph_dsc = getGlyphDscSun24,
    .get_glyph_bitmap = getGlyphBitmapSun24,
    .line_height = 24,
    .base_line = 2,
    .subpx = LV_FONT_SUBPX_NONE,
    .static_bitmap = 1,
    .underline_position = -2,
    .underline_thickness = 1,
};

const lv_font_t bluesquid_font_climate_24 = {
    .dsc = nullptr,
    .fallback = nullptr,
    .get_glyph_dsc = getGlyphDscClimate24,
    .get_glyph_bitmap = getGlyphBitmapClimate24,
    .line_height = 24,
    .base_line = 3,
    .subpx = LV_FONT_SUBPX_NONE,
    .static_bitmap = 1,
    .underline_position = -2,
    .underline_thickness = 1,
};
